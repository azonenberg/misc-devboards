kup-lulz-qsfp1-backtrim-viatrim.son:
```
FTYP SONPROJ 19 ! Sonnet Project File
VER 18.56
HEADER
LIC antikernel2.1.61468
DAT 03/15/2024 06:25:46
BUILT_BY_CREATED dxf 18.56 03/15/2024 05:41:27
BUILT_BY_SAVED sonnet 18.56
MDATE 03/15/2024 06:25:46
HDATE 03/15/2024 06:25:46
ANN Created by dxfgeo, Sonnet Software Inc.
END HEADER
DIM
ANG DEG
CAP PF
CON /OH
FREQ GHZ
IND NH
LNG MM
RES OH
END DIM
CONTROL
VARSWP
OPTIONS  -dj
SPEED 1
CACHE_ABS 2
Q_ACC N
END CONTROL
GEO
TMET "Lossless" 0 SUP 0 0 0 0
BMET "Lossless" 0 SUP 0 0 0 0
MET "Copper_1oz+plated_thick_up" 1 TMM 58000000 0.5 0.0432 2
MET "Copper_1oz+plated_thin" 4 NOR 58000000 0.5 0.0432 
MET "Copper_0.5oz_thin" 2 NOR 58000000 0.5 0.0175 
MET "Copper_1oz+plated_thick_down" 3 TMM 58000000 0.5 0.0432 2 CDVY TDWN
BOX 6 50 30 4000 2400 20 0
      10 1 1 0 0 0 0 "Air"
      0.05 3.5 1 0.02 0 0 0 "Soldermask"
      0.2021 3.61 1 0.0092 0 0 0 "Isola_FR408HR"
      1.1938 3.61 1 0.0092 0 0 0 "Isola_FR408HR"
      0.2021 3.61 1 0.0092 0 0 0 "Isola_FR408HR"
      0.05 3.5 1 0.02 0 0 0 "Soldermask"
      10 1 1 0 0 0 0 "Air"
TECHLAY METAL F.Cu_thick L1D0 -1 -65534 CAD F.Cu drawing 
1 0 0 N 2148 1 1 100 100 0 0 0 Y
END
END
TECHLAY VIA Via1 L5D0 -7 -65534 CAD Via1 drawing 
VIA POLYGON
1 0 -1 N 2200 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
END
END
TECHLAY METAL F.Cu_thin <UNSPECIFIED> -2 -65534 CAD F.Cu_thin drawing 
1 0 1 N 2160 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In1.Cu L2D0 -3 -65534 CAD In1.Cu drawing 
2 0 2 N 2163 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In2.Cu L3D0 -4 -65534 CAD In2.Cu drawing 
3 0 2 N 2166 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL B.Cu_thick L4D0 -5 -65534 CAD B.Cu drawing 
4 0 3 N 2169 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL B.Cu_thin <UNSPECIFIED> -6 -65534 CAD B.Cu_thin drawing 
4 0 1 N 2171 1 1 100 100 0 0 0 Y
END
END
LORGN 0 30 U 
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 2066 1
337
2 100 0 0 0 4.383 28.525 
CUPGRP "Auto" LOCAL
ID 2196
END
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 2068 1
540
-2 100 0 0 0 5.183 28.525 
CUPGRP "Auto" LOCAL
ID 2197
END
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 2073 1
35
1 100 0 0 0 42.675 2.74575 
CUPGRP "Auto" LOCAL
ID 2198
END
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 2074 1
33
-1 100 0 0 0 42.675 3.724 
CUPGRP "Auto" LOCAL
ID 2199
END
NUM 108
1 340 0 N 2066 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
4.545 28.506
4.555 28.473
4.558 28.439
4.558 27.04
4.682 26.916
4.688 26.909
4.694 26.9
4.699 26.892
4.702 26.883
4.705 26.873
4.707 26.864
4.708 26.854
4.708 19.143
6.203 17.649
11.916 17.649
11.926 17.648
11.935 17.646
11.945 17.643
11.954 17.64
11.962 17.635
11.971 17.629
11.978 17.623
12.184 17.417
12.19 17.41
12.193 17.405
12.196 17.402
12.197 17.4
12.2 17.397
12.206 17.39
12.212 17.382
12.212 17.381
12.216 17.375
12.217 17.373
12.217 17.372
12.224 17.359
12.229 17.35
12.233 17.341
12.243 17.306
12.245 17.297
12.246 17.287
12.246 17.279
12.248 17.271
12.249 17.261
12.249 17.251
12.245 17.215
12.243 17.206
12.24 17.196
12.237 17.189
12.237 17.187
12.236 17.185
12.235 17.181
12.235 17.18
12.233 17.171
12.229 17.162
12.224 17.154
12.216 17.139
12.216 17.138
12.215 17.136
12.212 17.131
12.206 17.122
12.2 17.115
12.193 17.107
12.191 17.104
12.19 17.102
12.189 17.101
12.188 17.099
12.183 17.094
12.176 17.084
12.174 17.082
12.171 17.073
12.171 17.06
12.172 17.059
12.179 17.045
12.181 17.042
12.184 17.039
12.415 16.809
12.419 16.805
12.422 16.804
12.424 16.802
12.433 16.799
12.446 16.799
12.447 16.8
12.463 16.808
12.467 16.812
12.494 16.834
12.502 16.84
12.503 16.84
12.509 16.844
12.511 16.845
12.512 16.845
12.526 16.852
12.534 16.857
12.543 16.861
12.578 16.871
12.587 16.873
12.597 16.874
12.605 16.874
12.613 16.876
12.623 16.877
12.633 16.877
12.669 16.873
12.678 16.871
12.688 16.868
12.689 16.868
12.703 16.863
12.704 16.863
12.713 16.861
12.722 16.857
12.753 16.84
12.762 16.834
12.769 16.828
12.776 16.821
12.78 16.818
12.782 16.817
12.789 16.811
19.868 9.732
19.875 9.726
19.882 9.719
19.888 9.712
19.894 9.703
19.899 9.695
19.902 9.686
19.905 9.676
19.907 9.667
19.908 9.657
19.908 6.193
21.203 4.899
36.113 4.899
36.123 4.898
36.133 4.896
36.151 4.89
36.157 4.886
36.158 4.886
36.178 4.892
36.2 4.897
36.222 4.899
36.244 4.899
36.266 4.897
36.288 4.892
36.309 4.886
36.329 4.877
36.349 4.867
36.367 4.855
36.384 4.841
36.4 4.825
36.414 4.808
36.426 4.79
36.436 4.77
36.445 4.75
36.451 4.729
36.456 4.707
36.458 4.685
36.458 4.663
36.456 4.641
36.451 4.619
36.445 4.598
36.436 4.578
36.426 4.558
36.414 4.54
36.4 4.523
36.384 4.507
36.367 4.493
36.349 4.481
36.329 4.471
36.309 4.462
36.288 4.456
36.266 4.451
36.244 4.449
36.222 4.449
36.2 4.451
36.178 4.456
36.157 4.462
36.137 4.471
36.117 4.481
36.099 4.493
36.082 4.507
36.066 4.523
36.052 4.54
36.04 4.558
36.03 4.578
36.021 4.598
36.015 4.619
36.01 4.641
36.008 4.663
36.008 4.685
36.009 4.699
21.156 4.699
21.146 4.7
21.136 4.702
21.118 4.708
21.11 4.713
21.101 4.719
21.093 4.725
19.734 6.085
19.728 6.092
19.722 6.101
19.717 6.109
19.714 6.118
19.711 6.128
19.709 6.137
19.708 6.147
19.708 9.609
12.657 16.661
12.655 16.663
12.646 16.67
12.643 16.672
12.639 16.674
12.632 16.676
12.63 16.676
12.617 16.674
12.612 16.672
12.607 16.668
12.606 16.668
12.601 16.663
12.594 16.657
12.593 16.657
12.592 16.656
12.573 16.64
12.557 16.63
12.549 16.627
12.547 16.626
12.541 16.622
12.533 16.617
12.524 16.614
12.489 16.603
12.48 16.601
12.47 16.6
12.459 16.6
12.455 16.599
12.454 16.599
12.444 16.598
12.434 16.598
12.424 16.599
12.423 16.599
12.408 16.601
12.398 16.602
12.389 16.603
12.379 16.606
12.374 16.608
12.373 16.609
12.371 16.609
12.37 16.61
12.366 16.611
12.364 16.611
12.354 16.614
12.345 16.617
12.313 16.634
12.305 16.64
12.298 16.646
12.291 16.653
12.287 16.656
12.285 16.657
12.277 16.663
12.035 16.906
12.029 16.913
12.028 16.915
12.019 16.926
12.013 16.933
12.012 16.934
12.002 16.95
12 16.954
12 16.956
11.994 16.965
11.989 16.973
11.986 16.982
11.975 17.017
11.973 17.026
11.972 17.036
11.972 17.047
11.971 17.051
11.971 17.052
11.97 17.062
11.97 17.072
11.971 17.082
11.971 17.083
11.973 17.098
11.974 17.108
11.975 17.117
11.978 17.127
11.98 17.132
11.981 17.133
11.981 17.135
11.982 17.136
11.982 17.14
11.983 17.142
11.986 17.152
11.989 17.161
12.006 17.193
12.012 17.201
12.018 17.208
12.025 17.215
12.027 17.218
12.028 17.219
12.03 17.223
12.038 17.231
12.04 17.235
12.046 17.245
12.048 17.252
12.048 17.254
12.046 17.267
12.04 17.277
12.034 17.285
11.87 17.449
6.156 17.449
6.146 17.45
6.136 17.452
6.118 17.458
6.11 17.463
6.101 17.469
6.093 17.475
6.087 17.482
4.548 19.021
4.541 19.027
4.534 19.034
4.534 19.035
4.528 19.042
4.522 19.05
4.517 19.059
4.511 19.077
4.509 19.087
4.508 19.097
4.508 26.808
4.475 26.841
4.45 26.827
4.417 26.817
4.383 26.814
4.349 26.817
4.316 26.827
4.286 26.843
4.259 26.865
4.237 26.892
4.221 26.922
4.211 26.955
4.208 26.989
4.208 28.439
4.211 28.473
4.221 28.506
4.231133333 28.525
4.534866667 28.525
4.545 28.506
END
1 72 0 N 2067 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
3.745 28.506
3.755 28.473
3.758 28.439
3.758 26.989
3.755 26.955
3.753 26.948
3.766 26.947
3.788 26.942
3.809 26.936
3.829 26.927
3.849 26.917
3.867 26.905
3.884 26.891
3.9 26.875
3.914 26.858
3.926 26.84
3.936 26.82
3.945 26.8
3.951 26.779
3.956 26.757
3.958 26.735
3.958 26.713
3.956 26.691
3.951 26.669
3.945 26.648
3.936 26.628
3.926 26.608
3.914 26.59
3.9 26.573
3.884 26.557
3.867 26.543
3.849 26.531
3.829 26.521
3.809 26.512
3.788 26.506
3.766 26.501
3.744 26.499
3.722 26.499
3.7 26.501
3.678 26.506
3.657 26.512
3.637 26.521
3.617 26.531
3.599 26.543
3.582 26.557
3.566 26.573
3.552 26.59
3.54 26.608
3.53 26.628
3.521 26.648
3.515 26.669
3.51 26.691
3.508 26.713
3.508 26.735
3.51 26.757
3.515 26.779
3.521 26.8
3.53 26.82
3.531 26.822
3.516 26.827
3.486 26.843
3.459 26.865
3.437 26.892
3.421 26.922
3.411 26.955
3.408 26.989
3.408 28.439
3.411 28.473
3.421 28.506
3.431133333 28.525
3.734866667 28.525
3.745 28.506
END
1 543 0 N 2068 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
5.345 28.506
5.355 28.473
5.358 28.439
5.358 26.989
5.355 26.955
5.345 26.922
5.329 26.892
5.307 26.865
5.28 26.843
5.25 26.827
5.217 26.817
5.183 26.814
5.166 26.816
5.058 26.708
5.058 20.753
5.061 20.724
5.067 20.703
5.081 20.678
5.095 20.661
5.114 20.645
5.136 20.633
5.158 20.627
5.187 20.624
5.188 20.624
5.198 20.623
5.231 20.62
5.236 20.62
5.241 20.619
5.242 20.619
5.251 20.617
5.261 20.614
5.264 20.613
5.303 20.601
5.312 20.598
5.32 20.593
5.322 20.592
5.351 20.576
5.359 20.572
5.368 20.566
5.375 20.56
5.398 20.541
5.402 20.539
5.416 20.525
5.422 20.518
5.423 20.517
5.445 20.49
5.451 20.484
5.456 20.475
5.461 20.467
5.462 20.464
5.472 20.445
5.477 20.437
5.482 20.428
5.485 20.419
5.488 20.409
5.498 20.378
5.498 20.377
5.501 20.367
5.503 20.358
5.504 20.348
5.504 20.347
5.507 20.314
5.508 20.304
5.508 20.144
5.507 20.134
5.504 20.101
5.504 20.096
5.503 20.091
5.503 20.09
5.501 20.081
5.498 20.071
5.497 20.068
5.485 20.029
5.482 20.02
5.477 20.012
5.476 20.01
5.46 19.981
5.456 19.973
5.45 19.964
5.444 19.957
5.425 19.934
5.423 19.93
5.409 19.916
5.402 19.91
5.401 19.909
5.374 19.887
5.368 19.881
5.359 19.876
5.351 19.871
5.348 19.87
5.329 19.86
5.321 19.855
5.312 19.85
5.303 19.847
5.293 19.844
5.262 19.834
5.261 19.834
5.251 19.831
5.242 19.829
5.232 19.828
5.231 19.828
5.198 19.825
5.188 19.824
5.187 19.824
5.158 19.821
5.137 19.815
5.112 19.801
5.095 19.787
5.079 19.768
5.067 19.746
5.061 19.724
5.058 19.695
5.058 19.287
6.347 17.999
12.06 17.999
12.07 17.998
12.079 17.996
12.089 17.993
12.098 17.99
12.106 17.985
12.115 17.979
12.122 17.973
20.232 9.864
20.238 9.856
20.244 9.847
20.249 9.839
20.255 9.821
20.257 9.811
20.258 9.801
20.258 7.484
20.259 7.47
20.263 7.457
20.272 7.44
20.278 7.433
20.285 7.427
20.3 7.419
20.31 7.416
20.322 7.415
20.327 7.415
20.366 7.411
20.375 7.409
20.385 7.407
20.391 7.404
20.394 7.403
20.399 7.402
20.403 7.401
20.408 7.4
20.418 7.397
20.42 7.396
20.427 7.393
20.429 7.392
20.442 7.386
20.444 7.385
20.451 7.382
20.452 7.382
20.453 7.381
20.455 7.38
20.46 7.377
20.491 7.355
20.499 7.349
20.506 7.342
20.51 7.336
20.512 7.334
20.514 7.333
20.53 7.317
20.552 7.285
20.557 7.277
20.561 7.268
20.562 7.264
20.572 7.244
20.575 7.235
20.577 7.225
20.581 7.21
20.584 7.201
20.586 7.191
20.588 7.164
20.589 7.158
20.589 6.875
20.588 6.865
20.588 6.864
20.587 6.853
20.587 6.849
20.586 6.839
20.584 6.83
20.583 6.828
20.581 6.821
20.581 6.817
20.579 6.813
20.577 6.804
20.576 6.8
20.575 6.795
20.572 6.785
20.571 6.783
20.568 6.776
20.567 6.774
20.556 6.75
20.551 6.742
20.545 6.734
20.544 6.733
20.536 6.722
20.535 6.721
20.531 6.714
20.525 6.706
20.516 6.697
20.514 6.696
20.497 6.679
20.49 6.673
20.481 6.667
20.477 6.665
20.474 6.662
20.473 6.662
20.469 6.658
20.453 6.648
20.451 6.647
20.45 6.647
20.418 6.631
20.409 6.628
20.399 6.626
20.384 6.622
20.375 6.619
20.365 6.617
20.338 6.615
20.332 6.614
20.327 6.614
20.309 6.612
20.306 6.612
20.284 6.601
20.281 6.599
20.279 6.597
20.271 6.587
20.263 6.572
20.26 6.562
20.258 6.545
20.258 6.337
21.347 5.249
36.009 5.249
36.008 5.263
36.008 5.285
36.01 5.307
36.015 5.329
36.021 5.35
36.03 5.37
36.04 5.39
36.052 5.408
36.066 5.425
36.082 5.441
36.099 5.455
36.117 5.467
36.137 5.477
36.157 5.486
36.178 5.492
36.2 5.497
36.222 5.499
36.244 5.499
36.266 5.497
36.288 5.492
36.309 5.486
36.329 5.477
36.349 5.467
36.367 5.455
36.384 5.441
36.4 5.425
36.414 5.408
36.426 5.39
36.436 5.37
36.445 5.35
36.451 5.329
36.456 5.307
36.458 5.285
36.458 5.263
36.456 5.241
36.451 5.219
36.445 5.198
36.436 5.178
36.426 5.158
36.414 5.14
36.4 5.123
36.384 5.107
36.367 5.093
36.349 5.081
36.329 5.071
36.309 5.062
36.288 5.056
36.266 5.051
36.244 5.049
36.222 5.049
36.2 5.051
36.178 5.056
36.157 5.062
36.151 5.058
36.142 5.055
36.132 5.052
36.123 5.05
36.113 5.049
21.291 5.049
21.281 5.051
21.272 5.054
21.271 5.055
21.266 5.057
21.263 5.058
21.262 5.058
21.246 5.068
21.238 5.074
20.084 6.229
20.078 6.236
20.072 6.245
20.067 6.253
20.064 6.262
20.061 6.272
20.059 6.281
20.058 6.291
20.058 6.554
20.059 6.564
20.061 6.586
20.062 6.596
20.064 6.606
20.066 6.613
20.067 6.615
20.076 6.646
20.08 6.655
20.085 6.663
20.094 6.681
20.095 6.684
20.1 6.692
20.106 6.701
20.112 6.708
20.125 6.724
20.126 6.726
20.132 6.733
20.139 6.74
20.171 6.767
20.18 6.772
20.188 6.777
20.197 6.781
20.198 6.781
20.202 6.783
20.209 6.788
20.217 6.792
20.226 6.796
20.267 6.809
20.276 6.81
20.286 6.811
20.308 6.813
20.309 6.813
20.318 6.814
20.319 6.814
20.335 6.816
20.344 6.818
20.355 6.823
20.368 6.832
20.373 6.838
20.381 6.849
20.383 6.853
20.384 6.856
20.386 6.861
20.387 6.866
20.389 6.893
20.389 7.145
20.387 7.161
20.385 7.17
20.378 7.185
20.378 7.186
20.376 7.187
20.362 7.201
20.359 7.203
20.347 7.209
20.332 7.213
20.329 7.214
20.318 7.214
20.31 7.215
20.308 7.215
20.286 7.217
20.276 7.218
20.266 7.22
20.259 7.222
20.257 7.223
20.226 7.232
20.217 7.236
20.208 7.241
20.202 7.244
20.2 7.246
20.197 7.248
20.193 7.249
20.188 7.251
20.18 7.256
20.171 7.262
20.139 7.288
20.132 7.295
20.132 7.296
20.125 7.304
20.12 7.311
20.105 7.328
20.1 7.337
20.095 7.345
20.092 7.352
20.091 7.354
20.085 7.365
20.084 7.367
20.08 7.373
20.08 7.374
20.079 7.377
20.077 7.382
20.076 7.383
20.074 7.39
20.074 7.392
20.067 7.413
20.064 7.423
20.062 7.432
20.058 7.474
20.058 9.754
12.014 17.799
6.291 17.799
6.281 17.801
6.272 17.804
6.271 17.805
6.266 17.807
6.263 17.808
6.262 17.808
6.246 17.818
6.238 17.824
4.884 19.179
4.878 19.186
4.872 19.195
4.867 19.203
4.864 19.212
4.861 19.222
4.859 19.231
4.858 19.241
4.858 19.704
4.859 19.714
4.862 19.747
4.862 19.748
4.863 19.758
4.865 19.767
4.868 19.777
4.868 19.778
4.878 19.809
4.881 19.819
4.884 19.828
4.889 19.837
4.894 19.845
4.904 19.864
4.905 19.867
4.91 19.875
4.915 19.884
4.921 19.89
4.943 19.917
4.944 19.918
4.95 19.925
4.964 19.939
4.968 19.941
4.991 19.96
4.998 19.966
5.007 19.972
5.015 19.976
5.044 19.992
5.046 19.993
5.054 19.998
5.063 20.001
5.102 20.013
5.105 20.014
5.115 20.017
5.124 20.019
5.125 20.019
5.13 20.02
5.135 20.02
5.168 20.023
5.178 20.024
5.179 20.024
5.208 20.027
5.23 20.033
5.252 20.045
5.271 20.061
5.285 20.078
5.299 20.103
5.305 20.124
5.308 20.153
5.308 20.295
5.305 20.324
5.299 20.346
5.287 20.368
5.271 20.387
5.254 20.401
5.229 20.415
5.208 20.421
5.179 20.424
5.178 20.424
5.168 20.425
5.135 20.428
5.134 20.428
5.124 20.429
5.115 20.431
5.105 20.434
5.104 20.434
5.073 20.444
5.063 20.447
5.054 20.45
5.045 20.455
5.037 20.46
5.018 20.47
5.015 20.471
5.007 20.476
4.998 20.481
4.992 20.487
4.965 20.509
4.964 20.51
4.957 20.516
4.943 20.53
4.941 20.534
4.922 20.557
4.916 20.564
4.91 20.573
4.906 20.581
4.89 20.61
4.889 20.612
4.884 20.62
4.881 20.629
4.869 20.668
4.868 20.671
4.865 20.681
4.863 20.69
4.863 20.691
4.862 20.696
4.862 20.701
4.859 20.734
4.858 20.744
4.858 26.754
4.859 26.764
4.861 26.773
4.864 26.783
4.867 26.792
4.872 26.8
4.878 26.809
4.884 26.816
5.014 26.946
5.011 26.955
5.008 26.989
5.008 28.439
5.011 28.473
5.021 28.506
5.031133333 28.525
5.334866667 28.525
5.345 28.506
END
1 67 0 N 2069 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
6.145 28.506
6.155 28.473
6.158 28.439
6.158 26.989
6.155 26.955
6.145 26.922
6.13 26.894
6.134 26.891
6.15 26.875
6.164 26.858
6.176 26.84
6.186 26.82
6.195 26.8
6.201 26.779
6.206 26.757
6.208 26.735
6.208 26.713
6.206 26.691
6.201 26.669
6.195 26.648
6.186 26.628
6.176 26.608
6.164 26.59
6.15 26.573
6.134 26.557
6.117 26.543
6.099 26.531
6.079 26.521
6.059 26.512
6.038 26.506
6.016 26.501
5.994 26.499
5.972 26.499
5.95 26.501
5.928 26.506
5.907 26.512
5.887 26.521
5.867 26.531
5.849 26.543
5.832 26.557
5.816 26.573
5.802 26.59
5.79 26.608
5.78 26.628
5.771 26.648
5.765 26.669
5.76 26.691
5.758 26.713
5.758 26.735
5.76 26.757
5.765 26.779
5.771 26.8
5.78 26.82
5.79 26.84
5.802 26.858
5.816 26.875
5.832 26.891
5.836 26.894
5.821 26.922
5.811 26.955
5.808 26.989
5.808 28.439
5.811 28.473
5.821 28.506
5.831133333 28.525
6.134866667 28.525
6.145 28.506
END
1 81 0 N 2073 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
42.166 3.247
42.188 3.242
42.209 3.236
42.229 3.227
42.249 3.217
42.267 3.205
42.284 3.191
42.3 3.175
42.314 3.158
42.326 3.14
42.336 3.12
42.345 3.1
42.351 3.079
42.356 3.057
42.358 3.035
42.358 3.013
42.356 2.991
42.351 2.969
42.346 2.952
42.376 2.922
42.387 2.927
42.407 2.936
42.428 2.942
42.45 2.947
42.472 2.949
42.494 2.949
42.516 2.947
42.538 2.942
42.559 2.936
42.579 2.927
42.599 2.917
42.617 2.905
42.634 2.891
42.65 2.875
42.664 2.858
42.675 2.8415
42.675 2.65
42.27042857 2.65
42.265 2.669
42.26 2.691
42.258 2.713
42.258 2.735
42.26 2.756
42.205 2.811
42.188 2.806
42.166 2.801
42.144 2.799
42.122 2.799
42.1 2.801
42.078 2.806
42.057 2.812
42.037 2.821
42.017 2.831
41.999 2.843
41.982 2.857
41.966 2.873
41.952 2.89
41.94 2.908
41.93 2.928
41.921 2.948
41.915 2.969
41.91 2.991
41.908 3.013
41.908 3.035
41.91 3.057
41.915 3.079
41.921 3.1
41.93 3.12
41.94 3.14
41.952 3.158
41.966 3.175
41.982 3.191
41.999 3.205
42.017 3.217
42.037 3.227
42.057 3.236
42.078 3.242
42.1 3.247
42.122 3.249
42.144 3.249
42.166 3.247
END
1 103 0 N 2074 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
42.166 4.297
42.188 4.292
42.209 4.286
42.229 4.277
42.249 4.267
42.267 4.255
42.284 4.241
42.3 4.225
42.314 4.208
42.326 4.19
42.336 4.17
42.345 4.15
42.351 4.129
42.356 4.107
42.358 4.085
42.358 4.063
42.356 4.041
42.351 4.019
42.346 4.002
42.411 3.937
42.428 3.942
42.45 3.947
42.472 3.949
42.494 3.949
42.516 3.947
42.538 3.942
42.559 3.936
42.579 3.927
42.599 3.917
42.617 3.905
42.634 3.891
42.65 3.875
42.664 3.858
42.675 3.8415
42.675 3.6065
42.664 3.59
42.65 3.573
42.634 3.557
42.617 3.543
42.599 3.531
42.579 3.521
42.559 3.512
42.538 3.506
42.516 3.501
42.494 3.499
42.472 3.499
42.45 3.501
42.428 3.506
42.407 3.512
42.387 3.521
42.367 3.531
42.349 3.543
42.332 3.557
42.316 3.573
42.302 3.59
42.29 3.608
42.28 3.628
42.271 3.648
42.265 3.669
42.26 3.691
42.258 3.713
42.258 3.735
42.26 3.757
42.265 3.779
42.27 3.796
42.205 3.861
42.188 3.856
42.166 3.851
42.144 3.849
42.122 3.849
42.1 3.851
42.078 3.856
42.057 3.862
42.037 3.871
42.017 3.881
41.999 3.893
41.982 3.907
41.966 3.923
41.952 3.94
41.94 3.958
41.93 3.978
41.921 3.998
41.915 4.019
41.91 4.041
41.908 4.063
41.908 4.085
41.91 4.107
41.915 4.129
41.921 4.15
41.93 4.17
41.94 4.19
41.952 4.208
41.966 4.225
41.982 4.241
41.999 4.255
42.017 4.267
42.037 4.277
42.057 4.286
42.078 4.292
42.1 4.297
42.122 4.299
42.144 4.299
42.166 4.297
END
VIA POLYGON
1 5 -1 N 1274 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
6.358 16.849
6.358 16.599
6.608 16.599
6.608 16.849
6.358 16.849
END
VIA POLYGON
1 5 -1 N 1275 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
7.358 16.849
7.358 16.599
7.608 16.599
7.608 16.849
7.358 16.849
END
VIA POLYGON
1 5 -1 N 1276 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
8.358 16.849
8.358 16.599
8.608 16.599
8.608 16.849
8.358 16.849
END
VIA POLYGON
1 5 -1 N 1277 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
9.358 16.849
9.358 16.599
9.608 16.599
9.608 16.849
9.358 16.849
END
VIA POLYGON
1 5 -1 N 1278 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
10.358 16.849
10.358 16.599
10.608 16.599
10.608 16.849
10.358 16.849
END
VIA POLYGON
1 5 -1 N 1279 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
11.358 16.849
11.358 16.599
11.608 16.599
11.608 16.849
11.358 16.849
END
VIA POLYGON
1 5 -1 N 1298 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
20.858 6.349
20.858 6.099
21.108 6.099
21.108 6.349
20.858 6.349
END
VIA POLYGON
1 5 -1 N 1304 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
36.108 6.099
36.108 5.849
36.358 5.849
36.358 6.099
36.108 6.099
END
VIA POLYGON
1 5 -1 N 1309 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
34.358 5.849
34.358 5.599
34.608 5.599
34.608 5.849
34.358 5.849
END
VIA POLYGON
1 5 -1 N 1310 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
36.108 5.399
36.108 5.149
36.358 5.149
36.358 5.399
36.108 5.399
END
VIA POLYGON
1 5 -1 N 1317 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
36.108 4.799
36.108 4.549
36.358 4.549
36.358 4.799
36.108 4.799
END
VIA POLYGON
1 5 -1 N 1321 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
37.358 4.349
37.358 4.099
37.608 4.099
37.608 4.349
37.358 4.349
END
VIA POLYGON
1 5 -1 N 1324 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
42.008 4.199
42.008 3.949
42.258 3.949
42.258 4.199
42.008 4.199
END
VIA POLYGON
1 5 -1 N 1328 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
36.108 4.099
36.108 3.849
36.358 3.849
36.358 4.099
36.108 4.099
END
VIA POLYGON
1 5 -1 N 1339 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
42.008 3.149
42.008 2.899
42.258 2.899
42.258 3.149
42.008 3.149
END
VIA POLYGON
1 5 -1 N 1376 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
29.858 5.849
29.858 5.599
30.108 5.599
30.108 5.849
29.858 5.849
END
VIA POLYGON
1 5 -1 N 1377 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
30.858 5.849
30.858 5.599
31.108 5.599
31.108 5.849
30.858 5.849
END
VIA POLYGON
1 5 -1 N 1378 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
18.858 5.849
18.858 5.599
19.108 5.599
19.108 5.849
18.858 5.849
END
VIA POLYGON
1 5 -1 N 1380 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
20.858 4.349
20.858 4.099
21.108 4.099
21.108 4.349
20.858 4.349
END
VIA POLYGON
1 5 -1 N 1381 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
21.858 4.349
21.858 4.099
22.108 4.099
22.108 4.349
21.858 4.349
END
VIA POLYGON
1 5 -1 N 1382 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
22.858 4.349
22.858 4.099
23.108 4.099
23.108 4.349
22.858 4.349
END
VIA POLYGON
1 5 -1 N 1383 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
23.858 4.349
23.858 4.099
24.108 4.099
24.108 4.349
23.858 4.349
END
VIA POLYGON
1 5 -1 N 1384 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
24.858 4.349
24.858 4.099
25.108 4.099
25.108 4.349
24.858 4.349
END
VIA POLYGON
1 5 -1 N 1389 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
25.858 4.349
25.858 4.099
26.108 4.099
26.108 4.349
25.858 4.349
END
VIA POLYGON
1 5 -1 N 1390 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
26.858 4.349
26.858 4.099
27.108 4.099
27.108 4.349
26.858 4.349
END
VIA POLYGON
1 5 -1 N 1391 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
27.858 4.349
27.858 4.099
28.108 4.099
28.108 4.349
27.858 4.349
END
VIA POLYGON
1 5 -1 N 1392 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
28.858 4.349
28.858 4.099
29.108 4.099
29.108 4.349
28.858 4.349
END
VIA POLYGON
1 5 -1 N 1393 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
29.858 4.349
29.858 4.099
30.108 4.099
30.108 4.349
29.858 4.349
END
VIA POLYGON
1 5 -1 N 1399 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
30.858 4.349
30.858 4.099
31.108 4.099
31.108 4.349
30.858 4.349
END
VIA POLYGON
1 5 -1 N 1400 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
21.858 5.849
21.858 5.599
22.108 5.599
22.108 5.849
21.858 5.849
END
VIA POLYGON
1 5 -1 N 1401 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
22.858 5.849
22.858 5.599
23.108 5.599
23.108 5.849
22.858 5.849
END
VIA POLYGON
1 5 -1 N 1402 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
23.858 5.849
23.858 5.599
24.108 5.599
24.108 5.849
23.858 5.849
END
VIA POLYGON
1 5 -1 N 1403 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
24.858 5.849
24.858 5.599
25.108 5.599
25.108 5.849
24.858 5.849
END
VIA POLYGON
1 5 -1 N 1404 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
25.858 5.849
25.858 5.599
26.108 5.599
26.108 5.849
25.858 5.849
END
VIA POLYGON
1 5 -1 N 1405 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
26.858 5.849
26.858 5.599
27.108 5.599
27.108 5.849
26.858 5.849
END
VIA POLYGON
1 5 -1 N 1406 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
27.858 5.849
27.858 5.599
28.108 5.599
28.108 5.849
27.858 5.849
END
VIA POLYGON
1 5 -1 N 1407 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
19.858 4.849
19.858 4.599
20.108 4.599
20.108 4.849
19.858 4.849
END
VIA POLYGON
1 5 -1 N 1408 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
28.858 5.849
28.858 5.599
29.108 5.599
29.108 5.849
28.858 5.849
END
VIA POLYGON
1 5 -1 N 1425 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
18.858 12.349
18.858 12.099
19.108 12.099
19.108 12.349
18.858 12.349
END
VIA POLYGON
1 5 -1 N 1429 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
19.858 11.349
19.858 11.099
20.108 11.099
20.108 11.349
19.858 11.349
END
VIA POLYGON
1 5 -1 N 1435 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
20.858 10.349
20.858 10.099
21.108 10.099
21.108 10.349
20.858 10.349
END
VIA POLYGON
1 5 -1 N 1444 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
18.858 9.349
18.858 9.099
19.108 9.099
19.108 9.349
18.858 9.349
END
VIA POLYGON
1 5 -1 N 1445 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
20.858 9.349
20.858 9.099
21.108 9.099
21.108 9.349
20.858 9.349
END
VIA POLYGON
1 5 -1 N 1449 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
18.858 8.349
18.858 8.099
19.108 8.099
19.108 8.349
18.858 8.349
END
VIA POLYGON
1 5 -1 N 1450 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
20.858 8.349
20.858 8.099
21.108 8.099
21.108 8.349
20.858 8.349
END
VIA POLYGON
1 5 -1 N 1460 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
18.858 7.349
18.858 7.099
19.108 7.099
19.108 7.349
18.858 7.349
END
VIA POLYGON
1 5 -1 N 1461 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
21.358 7.349
21.358 7.099
21.608 7.099
21.608 7.349
21.358 7.349
END
VIA POLYGON
1 5 -1 N 1638 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
12.858 15.349
12.858 15.099
13.108 15.099
13.108 15.349
12.858 15.349
END
VIA POLYGON
1 5 -1 N 1639 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
15.358 12.849
15.358 12.599
15.608 12.599
15.608 12.849
15.358 12.849
END
VIA POLYGON
1 5 -1 N 1640 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
17.358 10.849
17.358 10.599
17.608 10.599
17.608 10.849
17.358 10.849
END
VIA POLYGON
1 5 -1 N 1641 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
15.858 15.349
15.858 15.099
16.108 15.099
16.108 15.349
15.858 15.349
END
VIA POLYGON
1 5 -1 N 1642 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
16.858 14.349
16.858 14.099
17.108 14.099
17.108 14.349
16.858 14.349
END
VIA POLYGON
1 5 -1 N 1643 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
16.358 11.849
16.358 11.599
16.608 11.599
16.608 11.849
16.358 11.849
END
VIA POLYGON
1 5 -1 N 1651 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
17.858 13.349
17.858 13.099
18.108 13.099
18.108 13.349
17.858 13.349
END
VIA POLYGON
1 5 -1 N 1652 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
14.858 16.349
14.858 16.099
15.108 16.099
15.108 16.349
14.858 16.349
END
VIA POLYGON
1 5 -1 N 1655 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.608 26.849
3.608 26.599
3.858 26.599
3.858 26.849
3.608 26.849
END
VIA POLYGON
1 5 -1 N 1656 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
5.858 26.849
5.858 26.599
6.108 26.599
6.108 26.849
5.858 26.849
END
VIA POLYGON
1 5 -1 N 1668 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 25.349
3.858 25.099
4.108 25.099
4.108 25.349
3.858 25.349
END
VIA POLYGON
1 5 -1 N 1669 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
5.358 25.349
5.358 25.099
5.608 25.099
5.608 25.349
5.358 25.349
END
VIA POLYGON
1 5 -1 N 1674 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 24.349
3.858 24.099
4.108 24.099
4.108 24.349
3.858 24.349
END
VIA POLYGON
1 5 -1 N 1675 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
5.358 24.349
5.358 24.099
5.608 24.099
5.608 24.349
5.358 24.349
END
VIA POLYGON
1 5 -1 N 1681 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 23.349
3.858 23.099
4.108 23.099
4.108 23.349
3.858 23.349
END
VIA POLYGON
1 5 -1 N 1682 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
5.358 23.349
5.358 23.099
5.608 23.099
5.608 23.349
5.358 23.349
END
VIA POLYGON
1 5 -1 N 1687 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 22.349
3.858 22.099
4.108 22.099
4.108 22.349
3.858 22.349
END
VIA POLYGON
1 5 -1 N 1688 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
5.358 22.349
5.358 22.099
5.608 22.099
5.608 22.349
5.358 22.349
END
VIA POLYGON
1 5 -1 N 1693 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 21.349
3.858 21.099
4.108 21.099
4.108 21.349
3.858 21.349
END
VIA POLYGON
1 5 -1 N 1694 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
6.358 21.349
6.358 21.099
6.608 21.099
6.608 21.349
6.358 21.349
END
VIA POLYGON
1 5 -1 N 1700 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 20.349
3.858 20.099
4.108 20.099
4.108 20.349
3.858 20.349
END
VIA POLYGON
1 5 -1 N 1701 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
6.358 20.349
6.358 20.099
6.608 20.099
6.608 20.349
6.358 20.349
END
VIA POLYGON
1 5 -1 N 1704 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 19.349
3.858 19.099
4.108 19.099
4.108 19.349
3.858 19.349
END
VIA POLYGON
1 5 -1 N 1705 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
6.358 19.349
6.358 19.099
6.608 19.099
6.608 19.349
6.358 19.349
END
VIA POLYGON
1 5 -1 N 1706 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
7.358 18.849
7.358 18.599
7.608 18.599
7.608 18.849
7.358 18.849
END
VIA POLYGON
1 5 -1 N 1707 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
8.358 18.849
8.358 18.599
8.608 18.599
8.608 18.849
8.358 18.849
END
VIA POLYGON
1 5 -1 N 1708 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
9.358 18.849
9.358 18.599
9.608 18.599
9.608 18.849
9.358 18.849
END
VIA POLYGON
1 5 -1 N 1709 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
10.358 18.849
10.358 18.599
10.608 18.599
10.608 18.849
10.358 18.849
END
VIA POLYGON
1 5 -1 N 1710 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
11.358 18.849
11.358 18.599
11.608 18.599
11.608 18.849
11.358 18.849
END
VIA POLYGON
1 5 -1 N 1712 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
3.858 18.349
3.858 18.099
4.108 18.099
4.108 18.349
3.858 18.349
END
VIA POLYGON
1 5 -1 N 1713 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
12.858 18.349
12.858 18.099
13.108 18.099
13.108 18.349
12.858 18.349
END
VIA POLYGON
1 5 -1 N 1715 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
4.858 17.349
4.858 17.099
5.108 17.099
5.108 17.349
4.858 17.349
END
VIA POLYGON
1 5 -1 N 1716 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
13.858 17.349
13.858 17.099
14.108 17.099
14.108 17.349
13.858 17.349
END
VIA POLYGON
1 5 -1 N 2178 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
42.958 4.049
42.958 3.799
43.208 3.799
43.208 4.049
42.958 4.049
END
VIA POLYGON
1 5 -1 N 2179 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
41.958 6.549
41.958 6.299
42.208 6.299
42.208 6.549
41.958 6.549
END
VIA POLYGON
1 5 -1 N 2180 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
40.758 4.599
40.758 4.349
41.008 4.349
41.008 4.599
40.758 4.599
END
VIA POLYGON
1 5 -1 N 2181 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
38.958 4.599
38.958 4.349
39.208 4.349
39.208 4.599
38.958 4.599
END
VIA POLYGON
1 5 -1 N 2182 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
42.758 4.599
42.758 4.349
43.008 4.349
43.008 4.599
42.758 4.599
END
VIA POLYGON
1 5 -1 N 2183 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
39.958 6.099
39.958 5.849
40.208 5.849
40.208 6.099
39.958 6.099
END
VIA POLYGON
1 5 -1 N 2184 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
38.958 4.099
38.958 3.849
39.208 3.849
39.208 4.099
38.958 4.099
END
VIA POLYGON
1 5 -1 N 2185 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
41.958 6.049
41.958 5.799
42.208 5.799
42.208 6.049
41.958 6.049
END
VIA POLYGON
1 5 -1 N 2186 1 1 100 100 0 0 0 Y
TOLEVEL 4 RING NOCOVERS
TLAYNAM Via1 INH
40.908 4.099
40.908 3.849
41.158 3.849
41.158 4.099
40.908 4.099
END
2 65 2 N 506 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
36.222 5.499
36.2 5.497
36.178 5.492
36.157 5.486
36.137 5.477
36.117 5.467
36.099 5.455
36.082 5.441
36.066 5.425
36.052 5.408
36.04 5.39
36.03 5.37
36.021 5.35
36.015 5.329
36.01 5.307
36.008 5.285
36.008 5.263
36.01 5.241
36.015 5.219
36.021 5.198
36.03 5.178
36.04 5.158
36.052 5.14
36.066 5.123
36.082 5.107
36.099 5.093
36.117 5.081
36.137 5.071
36.157 5.062
36.178 5.056
36.2 5.051
36.222 5.049
36.244 5.049
36.266 5.051
36.288 5.056
36.309 5.062
36.329 5.071
36.349 5.081
36.367 5.093
36.384 5.107
36.4 5.123
36.414 5.14
36.426 5.158
36.436 5.178
36.445 5.198
36.451 5.219
36.456 5.241
36.458 5.263
36.458 5.285
36.456 5.307
36.451 5.329
36.445 5.35
36.436 5.37
36.426 5.39
36.414 5.408
36.4 5.425
36.384 5.441
36.367 5.455
36.349 5.467
36.329 5.477
36.309 5.486
36.288 5.492
36.266 5.497
36.244 5.499
36.222 5.499
END
2 65 2 N 512 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
36.222 4.899
36.2 4.897
36.178 4.892
36.157 4.886
36.137 4.877
36.117 4.867
36.099 4.855
36.082 4.841
36.066 4.825
36.052 4.808
36.04 4.79
36.03 4.77
36.021 4.75
36.015 4.729
36.01 4.707
36.008 4.685
36.008 4.663
36.01 4.641
36.015 4.619
36.021 4.598
36.03 4.578
36.04 4.558
36.052 4.54
36.066 4.523
36.082 4.507
36.099 4.493
36.117 4.481
36.137 4.471
36.157 4.462
36.178 4.456
36.2 4.451
36.222 4.449
36.244 4.449
36.266 4.451
36.288 4.456
36.309 4.462
36.329 4.471
36.349 4.481
36.367 4.493
36.384 4.507
36.4 4.523
36.414 4.54
36.426 4.558
36.436 4.578
36.445 4.598
36.451 4.619
36.456 4.641
36.458 4.663
36.458 4.685
36.456 4.707
36.451 4.729
36.445 4.75
36.436 4.77
36.426 4.79
36.414 4.808
36.4 4.825
36.384 4.841
36.367 4.855
36.349 4.867
36.329 4.877
36.309 4.886
36.288 4.892
36.266 4.897
36.244 4.899
36.222 4.899
END
2 65 2 N 514 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
42.122 4.299
42.1 4.297
42.078 4.292
42.057 4.286
42.037 4.277
42.017 4.267
41.999 4.255
41.982 4.241
41.966 4.225
41.952 4.208
41.94 4.19
41.93 4.17
41.921 4.15
41.915 4.129
41.91 4.107
41.908 4.085
41.908 4.063
41.91 4.041
41.915 4.019
41.921 3.998
41.93 3.978
41.94 3.958
41.952 3.94
41.966 3.923
41.982 3.907
41.999 3.893
42.017 3.881
42.037 3.871
42.057 3.862
42.078 3.856
42.1 3.851
42.122 3.849
42.144 3.849
42.166 3.851
42.188 3.856
42.209 3.862
42.229 3.871
42.249 3.881
42.267 3.893
42.284 3.907
42.3 3.923
42.314 3.94
42.326 3.958
42.336 3.978
42.345 3.998
42.351 4.019
42.356 4.041
42.358 4.063
42.358 4.085
42.356 4.107
42.351 4.129
42.345 4.15
42.336 4.17
42.326 4.19
42.314 4.208
42.3 4.225
42.284 4.241
42.267 4.255
42.249 4.267
42.229 4.277
42.209 4.286
42.188 4.292
42.166 4.297
42.144 4.299
42.122 4.299
END
2 65 2 N 523 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
42.122 3.249
42.1 3.247
42.078 3.242
42.057 3.236
42.037 3.227
42.017 3.217
41.999 3.205
41.982 3.191
41.966 3.175
41.952 3.158
41.94 3.14
41.93 3.12
41.921 3.1
41.915 3.079
41.91 3.057
41.908 3.035
41.908 3.013
41.91 2.991
41.915 2.969
41.921 2.948
41.93 2.928
41.94 2.908
41.952 2.89
41.966 2.873
41.982 2.857
41.999 2.843
42.017 2.831
42.037 2.821
42.057 2.812
42.078 2.806
42.1 2.801
42.122 2.799
42.144 2.799
42.166 2.801
42.188 2.806
42.209 2.812
42.229 2.821
42.249 2.831
42.267 2.843
42.284 2.857
42.3 2.873
42.314 2.89
42.326 2.908
42.336 2.928
42.345 2.948
42.351 2.969
42.356 2.991
42.358 3.013
42.358 3.035
42.356 3.057
42.351 3.079
42.345 3.1
42.336 3.12
42.326 3.14
42.314 3.158
42.3 3.175
42.284 3.191
42.267 3.205
42.249 3.217
42.229 3.227
42.209 3.236
42.188 3.242
42.166 3.247
42.144 3.249
42.122 3.249
END
2 117 2 N 2210 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
7 19.525
15.475 19.525
15.475 16.55
18.1 16.55
18.1 14.675
19.65 14.675
19.65 11.75
22.35 11.75
22.35 6.975
36.233 6.975
36.233 5.629
36.123 5.612
36.024 5.561
35.967 5.504
35.946 5.483
35.896 5.384
35.878 5.274
35.896 5.164
35.946 5.065
35.994 5.017
36.012 4.974
35.994 4.931
35.946 4.883
35.896 4.784
35.878 4.674
35.896 4.564
35.946 4.465
36.024 4.387
36.123 4.337
36.233 4.319
36.343 4.337
36.442 4.387
36.52 4.465
36.571 4.564
36.588 4.674
36.581 4.719
36.571 4.784
36.52 4.883
36.472 4.931
36.454 4.974
36.472 5.017
36.52 5.065
36.524 5.074
36.571 5.164
36.588 5.274
36.571 5.384
36.52 5.483
36.442 5.561
36.343 5.612
36.233 5.629
36.233 6.975
43.625 6.975
43.625 5.074
43.625 2.65
43.625 2.075
42.133 2.075
42.133 2.669
42.243 2.687
42.306 2.719
42.342 2.737
42.42 2.815
42.448 2.869
42.471 2.914
42.488 3.024
42.47409091 3.114
42.471 3.134
42.424 3.224
42.42 3.233
42.342 3.311
42.243 3.362
42.133 3.379
42.133 3.379
42.133 3.719
42.243 3.737
42.342 3.787
42.42 3.865
42.471 3.964
42.488 4.074
42.471 4.184
42.42 4.283
42.342 4.361
42.243 4.412
42.133 4.429
42.023 4.412
41.924 4.361
41.846 4.283
41.796 4.184
41.778 4.074
41.796 3.964
41.846 3.865
41.924 3.787
42.023 3.737
42.133 3.719
42.133 3.379
42.023 3.362
41.924 3.311
41.846 3.233
41.796 3.134
41.778 3.024
41.796 2.914
41.846 2.815
41.924 2.737
42.023 2.687
42.133 2.669
42.133 2.075
40.175 2.075
40.175 2.65
18.1 2.65
18.1 9.525
13.625 9.525
13.625 13.3
11.325 13.3
11.325 15.225
2.875 15.225
2.875 29.425
7 29.425
7 19.525
END
3 65 2 N 645 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu INH
36.222 5.499
36.2 5.497
36.178 5.492
36.157 5.486
36.137 5.477
36.117 5.467
36.099 5.455
36.082 5.441
36.066 5.425
36.052 5.408
36.04 5.39
36.03 5.37
36.021 5.35
36.015 5.329
36.01 5.307
36.008 5.285
36.008 5.263
36.01 5.241
36.015 5.219
36.021 5.198
36.03 5.178
36.04 5.158
36.052 5.14
36.066 5.123
36.082 5.107
36.099 5.093
36.117 5.081
36.137 5.071
36.157 5.062
36.178 5.056
36.2 5.051
36.222 5.049
36.244 5.049
36.266 5.051
36.288 5.056
36.309 5.062
36.329 5.071
36.349 5.081
36.367 5.093
36.384 5.107
36.4 5.123
36.414 5.14
36.426 5.158
36.436 5.178
36.445 5.198
36.451 5.219
36.456 5.241
36.458 5.263
36.458 5.285
36.456 5.307
36.451 5.329
36.445 5.35
36.436 5.37
36.426 5.39
36.414 5.408
36.4 5.425
36.384 5.441
36.367 5.455
36.349 5.467
36.329 5.477
36.309 5.486
36.288 5.492
36.266 5.497
36.244 5.499
36.222 5.499
END
3 65 2 N 651 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu INH
36.222 4.899
36.2 4.897
36.178 4.892
36.157 4.886
36.137 4.877
36.117 4.867
36.099 4.855
36.082 4.841
36.066 4.825
36.052 4.808
36.04 4.79
36.03 4.77
36.021 4.75
36.015 4.729
36.01 4.707
36.008 4.685
36.008 4.663
36.01 4.641
36.015 4.619
36.021 4.598
36.03 4.578
36.04 4.558
36.052 4.54
36.066 4.523
36.082 4.507
36.099 4.493
36.117 4.481
36.137 4.471
36.157 4.462
36.178 4.456
36.2 4.451
36.222 4.449
36.244 4.449
36.266 4.451
36.288 4.456
36.309 4.462
36.329 4.471
36.349 4.481
36.367 4.493
36.384 4.507
36.4 4.523
36.414 4.54
36.426 4.558
36.436 4.578
36.445 4.598
36.451 4.619
36.456 4.641
36.458 4.663
36.458 4.685
36.456 4.707
36.451 4.729
36.445 4.75
36.436 4.77
36.426 4.79
36.414 4.808
36.4 4.825
36.384 4.841
36.367 4.855
36.349 4.867
36.329 4.877
36.309 4.886
36.288 4.892
36.266 4.897
36.244 4.899
36.222 4.899
END
3 65 2 N 654 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu INH
42.122 4.299
42.1 4.297
42.078 4.292
42.057 4.286
42.037 4.277
42.017 4.267
41.999 4.255
41.982 4.241
41.966 4.225
41.952 4.208
41.94 4.19
41.93 4.17
41.921 4.15
41.915 4.129
41.91 4.107
41.908 4.085
41.908 4.063
41.91 4.041
41.915 4.019
41.921 3.998
41.93 3.978
41.94 3.958
41.952 3.94
41.966 3.923
41.982 3.907
41.999 3.893
42.017 3.881
42.037 3.871
42.057 3.862
42.078 3.856
42.1 3.851
42.122 3.849
42.144 3.849
42.166 3.851
42.188 3.856
42.209 3.862
42.229 3.871
42.249 3.881
42.267 3.893
42.284 3.907
42.3 3.923
42.314 3.94
42.326 3.958
42.336 3.978
42.345 3.998
42.351 4.019
42.356 4.041
42.358 4.063
42.358 4.085
42.356 4.107
42.351 4.129
42.345 4.15
42.336 4.17
42.326 4.19
42.314 4.208
42.3 4.225
42.284 4.241
42.267 4.255
42.249 4.267
42.229 4.277
42.209 4.286
42.188 4.292
42.166 4.297
42.144 4.299
42.122 4.299
END
3 65 2 N 662 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu INH
42.122 3.249
42.1 3.247
42.078 3.242
42.057 3.236
42.037 3.227
42.017 3.217
41.999 3.205
41.982 3.191
41.966 3.175
41.952 3.158
41.94 3.14
41.93 3.12
41.921 3.1
41.915 3.079
41.91 3.057
41.908 3.035
41.908 3.013
41.91 2.991
41.915 2.969
41.921 2.948
41.93 2.928
41.94 2.908
41.952 2.89
41.966 2.873
41.982 2.857
41.999 2.843
42.017 2.831
42.037 2.821
42.057 2.812
42.078 2.806
42.1 2.801
42.122 2.799
42.144 2.799
42.166 2.801
42.188 2.806
42.209 2.812
42.229 2.821
42.249 2.831
42.267 2.843
42.284 2.857
42.3 2.873
42.314 2.89
42.326 2.908
42.336 2.928
42.345 2.948
42.351 2.969
42.356 2.991
42.358 3.013
42.358 3.035
42.356 3.057
42.351 3.079
42.345 3.1
42.336 3.12
42.326 3.14
42.314 3.158
42.3 3.175
42.284 3.191
42.267 3.205
42.249 3.217
42.229 3.227
42.209 3.236
42.188 3.242
42.166 3.247
42.144 3.249
42.122 3.249
END
3 109 2 N 2134 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu INH
43.625 6.975
43.625 6.175
43.625 5.074
43.625 2.65
43.625 2.075
42.133 2.075
42.133 2.669
42.243 2.687
42.342 2.737
42.42 2.815
42.448 2.869
42.471 2.914
42.488 3.024
42.47409091 3.114
42.47409091 3.114
42.471 3.134
42.424 3.224
42.42 3.233
42.342 3.311
42.243 3.362
42.133 3.379
42.133 3.379
42.133 3.719
42.133 3.719
42.243 3.737
42.342 3.787
42.42 3.865
42.471 3.964
42.488 4.074
42.471 4.184
42.42 4.283
42.342 4.361
42.243 4.412
42.133 4.429
42.093 4.422818182
42.023 4.412
41.924 4.361
41.846 4.283
41.796 4.184
41.778 4.074
41.796 3.964
41.846 3.865
41.924 3.787
42.023 3.737
42.133 3.719
42.133 3.379
42.023 3.362
41.924 3.311
41.846 3.233
41.796 3.134
41.778 3.024
41.796 2.914
41.846 2.815
41.924 2.737
42.023 2.687
42.133 2.669
42.133 2.075
40.175 2.075
40.175 2.65
38.675 2.65
38.675 2.65
32.75 2.65
32.75 6.975
36.233 6.975
36.233 5.629
36.123 5.612
36.024 5.561
35.967 5.504
35.946 5.483
35.896 5.384
35.878 5.274
35.896 5.164
35.946 5.065
35.994 5.017
36.012 4.974
35.994 4.931
35.946 4.883
35.896 4.784
35.878 4.674
35.896 4.564
35.946 4.465
36.024 4.387
36.123 4.337
36.233 4.319
36.343 4.337
36.442 4.387
36.52 4.465
36.571 4.564
36.588 4.674
36.581 4.719
36.571 4.784
36.52 4.883
36.472 4.931
36.454 4.974
36.472 5.017
36.52 5.065
36.524 5.074
36.571 5.164
36.588 5.274
36.571 5.384
36.52 5.483
36.442 5.561
36.343 5.612
36.233 5.629
36.233 6.975
42.525 6.975
42.525 6.975
43.625 6.975
43.625 6.975
END
4 397 3 N 839 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu_thick INH
38.953 6.017
38.892 6.011
38.883 6.009
38.873 6.006
38.868 6.005
38.864 6.003
38.836 5.994
38.834 5.994
38.816 5.988
38.808 5.983
38.806 5.982
38.774 5.965
38.771 5.964
38.755 5.954
38.754 5.953
38.747 5.947
38.718 5.923
38.716 5.922
38.708 5.915
38.701 5.908
38.695 5.901
38.694 5.9
38.669 5.869
38.663 5.862
38.657 5.853
38.652 5.845
38.651 5.842
38.638 5.817
38.633 5.809
38.628 5.8
38.624 5.791
38.607 5.733
38.605 5.724
38.604 5.714
38.604 5.713
38.599 5.663
38.599 5.661
38.597 5.634
38.589 5.604
38.576 5.577
38.56 5.555
38.543 5.538
38.52 5.521
38.493 5.509
38.467 5.502
38.437 5.499
38.156 5.499
38.146 5.498
38.136 5.496
38.118 5.49
38.109 5.485
38.101 5.479
38.094 5.473
38.093 5.473
38.086 5.466
38.08 5.459
37.87 5.249
36.457 5.249
36.458 5.263
36.458 5.285
36.456 5.307
36.451 5.329
36.445 5.35
36.436 5.37
36.426 5.39
36.414 5.408
36.4 5.425
36.384 5.441
36.367 5.455
36.349 5.467
36.329 5.477
36.309 5.486
36.288 5.492
36.266 5.497
36.244 5.499
36.222 5.499
36.2 5.497
36.178 5.492
36.157 5.486
36.137 5.477
36.117 5.467
36.099 5.455
36.082 5.441
36.066 5.425
36.052 5.408
36.04 5.39
36.03 5.37
36.021 5.35
36.015 5.329
36.01 5.307
36.008 5.285
36.008 5.263
36.01 5.241
36.015 5.219
36.021 5.198
36.03 5.178
36.04 5.158
36.052 5.14
36.066 5.123
36.082 5.107
36.099 5.093
36.117 5.081
36.137 5.071
36.157 5.062
36.178 5.056
36.2 5.051
36.222 5.049
36.244 5.049
36.266 5.051
36.288 5.056
36.309 5.062
36.315 5.058
36.324 5.055
36.334 5.052
36.343 5.05
36.353 5.049
37.916 5.049
37.926 5.05
37.935 5.052
37.945 5.055
37.954 5.058
37.962 5.063
37.971 5.069
37.978 5.075
37.985 5.082
37.991 5.089
38.202 5.299
38.445 5.299
38.455 5.3
38.487 5.303
38.496 5.304
38.499 5.304
38.501 5.305
38.506 5.305
38.508 5.306
38.515 5.307
38.518 5.308
38.519 5.308
38.558 5.319
38.559 5.319
38.562 5.32
38.567 5.322
38.577 5.327
38.604 5.34
38.605 5.34
38.614 5.344
38.622 5.349
38.623 5.35
38.633 5.356
38.636 5.359
38.649 5.369
38.657 5.374
38.659 5.376
38.666 5.38
38.668 5.382
38.673 5.386
38.675 5.387
38.682 5.394
38.685 5.398
38.7 5.413
38.704 5.416
38.711 5.423
38.712 5.425
38.716 5.43
38.718 5.432
38.724 5.44
38.725 5.442
38.742 5.466
38.748 5.474
38.753 5.482
38.77 5.518
38.771 5.52
38.775 5.529
38.779 5.541
38.779 5.543
38.79 5.579
38.79 5.581
38.793 5.591
38.794 5.597
38.794 5.599
38.795 5.611
38.798 5.643
38.799 5.654
38.803 5.69
38.811 5.718
38.826 5.746
38.846 5.77
38.867 5.788
38.898 5.804
38.93 5.814
38.962 5.817
39.037 5.817
39.067 5.814
39.093 5.807
39.12 5.795
39.143 5.778
39.16 5.761
39.177 5.737
39.188 5.715
39.197 5.682
39.199 5.655
39.199 5.654
39.204 5.599
39.205 5.597
39.205 5.592
39.206 5.59
39.207 5.583
39.208 5.58
39.208 5.579
39.219 5.54
39.219 5.539
39.22 5.536
39.222 5.531
39.227 5.521
39.24 5.494
39.24 5.493
39.244 5.484
39.249 5.476
39.25 5.475
39.256 5.465
39.259 5.462
39.269 5.449
39.274 5.441
39.276 5.439
39.28 5.432
39.282 5.43
39.286 5.425
39.287 5.423
39.294 5.416
39.298 5.413
39.313 5.398
39.316 5.394
39.323 5.387
39.325 5.386
39.33 5.382
39.332 5.38
39.34 5.374
39.342 5.373
39.362 5.359
39.365 5.356
39.373 5.35
39.381 5.345
39.42 5.327
39.424 5.325
39.429 5.323
39.431 5.322
39.44 5.319
39.445 5.318
39.479 5.308
39.481 5.308
39.491 5.305
39.497 5.304
39.499 5.304
39.511 5.303
39.543 5.3
39.553 5.299
41.095 5.299
42.033 4.361
42.033 4.275
42.017 4.267
41.999 4.255
41.982 4.241
41.966 4.225
41.952 4.208
41.94 4.19
41.93 4.17
41.921 4.15
41.915 4.129
41.91 4.107
41.908 4.085
41.908 4.063
41.91 4.041
41.915 4.019
41.921 3.998
41.93 3.978
41.94 3.958
41.952 3.94
41.966 3.923
41.982 3.907
41.999 3.893
42.017 3.881
42.037 3.871
42.057 3.862
42.078 3.856
42.1 3.851
42.122 3.849
42.144 3.849
42.166 3.851
42.188 3.856
42.209 3.862
42.229 3.871
42.249 3.881
42.267 3.893
42.284 3.907
42.3 3.923
42.314 3.94
42.326 3.958
42.336 3.978
42.345 3.998
42.351 4.019
42.356 4.041
42.358 4.063
42.358 4.085
42.356 4.107
42.351 4.129
42.345 4.15
42.336 4.17
42.326 4.19
42.314 4.208
42.3 4.225
42.284 4.241
42.267 4.255
42.249 4.267
42.233 4.275
42.233 4.407
42.232 4.417
42.23 4.427
42.224 4.445
42.219 4.454
42.213 4.462
42.207 4.469
41.203 5.473
41.196 5.479
41.188 5.485
41.187 5.485
41.185 5.487
41.179 5.49
41.161 5.496
41.151 5.498
41.141 5.499
39.561 5.499
39.534 5.501
39.501 5.51
39.479 5.521
39.455 5.538
39.438 5.555
39.421 5.578
39.409 5.605
39.402 5.631
39.399 5.661
39.399 5.662
39.394 5.717
39.394 5.719
39.393 5.725
39.39 5.735
39.39 5.737
39.38 5.771
39.379 5.776
39.376 5.785
39.375 5.787
39.373 5.792
39.371 5.796
39.353 5.835
39.348 5.843
39.342 5.851
39.339 5.854
39.325 5.874
39.324 5.876
39.318 5.884
39.316 5.886
39.312 5.891
39.311 5.893
39.304 5.9
39.3 5.903
39.285 5.918
39.282 5.922
39.275 5.929
39.273 5.93
39.268 5.934
39.266 5.936
39.259 5.94
39.257 5.942
39.249 5.947
39.236 5.957
39.233 5.96
39.223 5.966
39.222 5.967
39.214 5.972
39.205 5.976
39.204 5.976
39.177 5.989
39.167 5.994
39.162 5.996
39.159 5.997
39.158 5.997
39.119 6.008
39.118 6.008
39.115 6.009
39.108 6.01
39.106 6.011
39.101 6.011
39.099 6.012
39.096 6.012
39.087 6.013
39.055 6.016
39.045 6.017
38.953 6.017
END
4 161 3 N 847 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu_thick INH
38.3 5.149
38.29 5.148
38.281 5.146
38.271 5.143
38.262 5.14
38.254 5.135
38.245 5.129
38.238 5.123
38.014 4.899
36.353 4.899
36.343 4.898
36.334 4.896
36.324 4.893
36.315 4.89
36.309 4.886
36.288 4.892
36.266 4.897
36.244 4.899
36.222 4.899
36.2 4.897
36.178 4.892
36.157 4.886
36.137 4.877
36.117 4.867
36.099 4.855
36.082 4.841
36.066 4.825
36.052 4.808
36.04 4.79
36.03 4.77
36.021 4.75
36.015 4.729
36.01 4.707
36.008 4.685
36.008 4.663
36.01 4.641
36.015 4.619
36.021 4.598
36.03 4.578
36.04 4.558
36.052 4.54
36.066 4.523
36.082 4.507
36.099 4.493
36.117 4.481
36.137 4.471
36.157 4.462
36.178 4.456
36.2 4.451
36.222 4.449
36.244 4.449
36.266 4.451
36.288 4.456
36.309 4.462
36.329 4.471
36.349 4.481
36.367 4.493
36.384 4.507
36.4 4.523
36.414 4.54
36.426 4.558
36.436 4.578
36.445 4.598
36.451 4.619
36.456 4.641
36.458 4.663
36.458 4.685
36.457 4.699
38.06 4.699
38.07 4.7
38.08 4.702
38.098 4.708
38.107 4.713
38.115 4.719
38.122 4.725
38.123 4.725
38.13 4.732
38.136 4.739
38.346 4.949
40.939 4.949
41.408 4.48
41.408 3.644
41.409 3.634
41.411 3.625
41.414 3.615
41.417 3.606
41.422 3.598
41.428 3.589
41.434 3.582
41.92 3.096
41.915 3.079
41.91 3.057
41.908 3.035
41.908 3.013
41.91 2.991
41.915 2.969
41.921 2.948
41.93 2.928
41.94 2.908
41.952 2.89
41.966 2.873
41.982 2.857
41.999 2.843
42.017 2.831
42.037 2.821
42.057 2.812
42.078 2.806
42.1 2.801
42.122 2.799
42.144 2.799
42.166 2.801
42.188 2.806
42.209 2.812
42.229 2.821
42.249 2.831
42.267 2.843
42.284 2.857
42.3 2.873
42.314 2.89
42.326 2.908
42.336 2.928
42.345 2.948
42.351 2.969
42.356 2.991
42.358 3.013
42.358 3.035
42.356 3.057
42.351 3.079
42.345 3.1
42.336 3.12
42.326 3.14
42.314 3.158
42.3 3.175
42.284 3.191
42.267 3.205
42.249 3.217
42.229 3.227
42.209 3.236
42.188 3.242
42.166 3.247
42.144 3.249
42.122 3.249
42.1 3.247
42.078 3.242
42.061 3.237
41.608 3.69
41.608 4.526
41.607 4.536
41.603 4.554
41.599 4.564
41.589 4.58
41.582 4.588
41.047 5.123
41.04 5.129
41.031 5.135
41.023 5.14
41.014 5.143
41.004 5.146
40.995 5.148
40.985 5.149
38.3 5.149
END
4 4 3 N 2021 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu_thick INH
43.625 2.65
43.61414653 2.65
43.625 2.660875
43.625 2.65
END
END GEO
OPT
MAX 100
END OPT
VARSWP
ENABLED Y
FREQ Y AN SWEEP 5.0 40.0 5.0
END
END VARSWP
```
